<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32WBA55_BLE_P2PServer_EXT_ATT.ewp</path>
  </project>
  <batchBuild />
</workspace>
